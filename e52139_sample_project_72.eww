<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\e52139_sample_project_72.ewp</path>
  </project>
  <batchBuild/>
</workspace>


