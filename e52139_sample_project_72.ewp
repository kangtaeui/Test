# IAR project e52139_sample_project_72.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430_EL_E52139B EL_E52139B
  General.GStackSize2: 256
  General.GHeapSize2: 4
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEBUG; ELMOS_LIN
  ICC430.newCCIncludePaths: source/; source/HAL/; source/HAL/includes/; source/HAL/irq/; source/HAL/LINDrv/includes/; source/HAL/LINDrv/includes/interfaces/; source/HAL/LINDrv/devices/; source/HAL/LINDrv/devices/Bus/; source/HAL/ROMInterface/; source/HAL/modules/eeprom_access/; source/LIN/; source/DRV/; source/APP/
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: linker\lnkEL_E52139B_APP_721.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    source/: main.c
  group HAL
    source/HAL/irq/: CommonInterruptHandler.c
    source/HAL/includes/: el_helper_H430_IAR.c
    source/HAL/: HalGpio.c HalSys.c HalTimer.c
    source/HAL/RomInterface/: rom_API.c
